# Keil uVision project mpu6050.uvprojx, settings and files
target mpu6050 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: mpu6050 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,USE_HAL_DRIVER,STM32L431xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\system\sys;..\system\usart;..\Hardwear\mpu6050;..\system\delay;..\Hardwear\LED;..\Hardwear\buzzer;..\Hardwear\EXTI;..\Hardwear\I2C;..\Hardwear\SPI;..\Hardwear\Kalman;..\Hardwear\ms5611;..\Hardwear\m5311;..\Hardwear\TIMER;..\Hardwear\bh1750;..\Drivers\STM32L4xx_HAL_Driver\Inc;.\L4_AI;..\system\dma;..\FreeRTOS\include;..\FreeRTOS\portable\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Hardwear
    ../Hardwear/mpu6050/: mpu6050.c
    ../Hardwear/ms5611/: ms5611.c
    ../Hardwear/LED/: LED.c
    ../Hardwear/buzzer/: buzzer.c
    ../Hardwear/Kalman/: kalman.c
    ../Hardwear/SPI/: spi.c
    ./L4_AI/: NanoEdgeAI.h
    ../Hardwear/EXTI/: exti.c
    ../Hardwear/I2C/: i2c.c
    ../Hardwear/m5311/: M5311.c
    ../Hardwear/TIMER/: timer.c
    ../Hardwear/bh1750/: bh1750.c
  group system
    ../system/sys/: sys.c
    ../system/usart/: usart.c
    ../system/delay/: delay.c
    ../system/dma/: dma.c dma.h
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c freertos_demo.c
    ./L4_AI/: libneai.a
    ../Inc/: FreeRTOSConfig.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group FreeRTOS/Source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
